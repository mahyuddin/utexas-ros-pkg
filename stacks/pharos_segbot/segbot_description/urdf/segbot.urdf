Commit message: fixed typo in urdf

File: stacks/pharos_segbot/segbot_description/urdf/segbot.urdf (robot description, URDF)
Before this commit: robot myfirst, 9 links, 8 joints
Links:
- link camera_link: geometry visual mesh filename=package://segbot_description/meshes/kinect.dae
